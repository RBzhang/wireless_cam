options:
  parameters:
    generate_options: qt_gui
    id: pm_loop_usrp
    output_language: python
    title: pm_loop_usrp
  states: {}

blocks:
- name: frame_height
  id: variable
  parameters:
    value: '1080'
  states: {}
- name: frame_width
  id: variable
  parameters:
    value: '1920'
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '30'
    value: '1'
  states: {}
- name: if_freq
  id: variable
  parameters:
    comment: Digital IF offset from the 900 MHz RF center
    value: 100e3
  states: {}
- name: max_phase
  id: variable
  parameters:
    value: math.pi/3
  states: {}
- name: noise
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.01'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 0.5e6
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '1'
    type: float
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: noise
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {state: disabled}
- name: analog_rail_ff_0
  id: analog_rail_ff
  parameters:
    hi: '1'
    lo: '0'
  states: {}
- name: band_reject_filter_0
  id: band_reject_filter
  parameters:
    comment: Reject downconverted LO/DC leakage and IQ image at +/-100 kHz
    decim: '1'
    gain: '1'
    high_cutoff_freq: 110e3
    low_cutoff_freq: 90e3
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 5e3
    win: window.WIN_HAMMING
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_complex_to_magphase_0
  id: blocks_complex_to_magphase
  parameters: {}
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: phase_rx.dat
    type: float
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: phase_tx.dat
    type: float
  states: {}
- name: blocks_file_sink_0_1
  id: blocks_file_sink
  parameters:
    file: iq_rx.dat
    type: complex
  states: {state: disabled}
- name: blocks_float_to_uchar_0
  id: blocks_float_to_uchar
  parameters:
    bias: '0'
    scale: '255'
    vlen: '1'
  states: {}
- name: blocks_magphase_to_complex_0
  id: blocks_magphase_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    comment: multiply with max_phase
    const: max_phase
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    comment: divide pi/3
    const: 3/math.pi
    type: float
  states: {}
- name: blocks_multiply_const_vxx_scale
  id: blocks_multiply_const_vxx
  parameters:
    const: 1.0/255.0
    type: float
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_phase_shift_0
  id: blocks_phase_shift
  parameters:
    is_radians: 'True'
    shift: math.pi/3
  states: {state: disabled}
- name: blocks_rotator_cc_rx
  id: blocks_rotator_cc
  parameters:
    comment: Downconvert 900.1 MHz received signal to complex baseband
    phase_inc: '-2*math.pi*if_freq/samp_rate'
  states: {}
- name: blocks_rotator_cc_tx
  id: blocks_rotator_cc
  parameters:
    comment: Shift PM complex envelope to 900.1 MHz RF
    phase_inc: 2*math.pi*if_freq/samp_rate
  states: {}
- name: blocks_uchar_to_float_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: from _image_sink_impl import image_byte_sink
    display: 'True'
    height: frame_height
    output_path: '"received.png"'
    save_sequence: 'False'
    skip_each_frame: '0'
    width: frame_width
  states: {}
- name: image_byte_source_0
  id: epy_block
  parameters:
    _source_code: from _image_source_impl import image_byte_source
    image_path: '"1920x1080.jpg"'
    repeat: 'True'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: pilot_sync_0
  id: epy_block
  parameters:
    _source_code: from _pilot_sync_impl import pilot_sync
    frame_size: frame_width*frame_height
    pilot_len: '1024'
    sync_len: '416'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_1_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_1_1
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    bw0: 5*samp_rate
    center_freq0: 900e6
    gain0: '1'
    gain_type0: normalized
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    bw0: 5*samp_rate
    center_freq0: 900e6
    gain0: gain
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: rx
  states: {state: disabled}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: tx
  states: {state: disabled}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: rx
  states: {state: disabled}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: tx
  states: {state: disabled}

connections:
- [analog_const_source_x_0, '0', blocks_magphase_to_complex_0, '0']
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '1']
- [analog_rail_ff_0, '0', blocks_float_to_uchar_0, '0']
- [band_reject_filter_0, '0', blocks_complex_to_magphase_0, '0']
- [blocks_add_xx_0, '0', virtual_sink_0, '0']
- [blocks_complex_to_magphase_0, '0', blocks_null_sink_0, '0']
- [blocks_complex_to_magphase_0, '1', blocks_file_sink_0, '0']
- [blocks_complex_to_magphase_0, '1', pilot_sync_0, '0']
- [blocks_complex_to_magphase_0, '1', qtgui_time_sink_x_1, '0']
- [blocks_float_to_uchar_0, '0', epy_block_0, '0']
- [blocks_magphase_to_complex_0, '0', blocks_rotator_cc_tx, '0']
- [blocks_magphase_to_complex_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_magphase_to_complex_0, '0', virtual_sink_1, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_file_sink_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_magphase_to_complex_0, '1']
- [blocks_multiply_const_vxx_0, '0', qtgui_time_sink_x_1_0, '0']
- [blocks_multiply_const_vxx_1, '0', analog_rail_ff_0, '0']
- [blocks_multiply_const_vxx_scale, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_phase_shift_0, '0', blocks_add_xx_0, '0']
- [blocks_rotator_cc_rx, '0', band_reject_filter_0, '0']
- [blocks_rotator_cc_rx, '0', blocks_file_sink_0_1, '0']
- [blocks_rotator_cc_tx, '0', uhd_usrp_sink_0, '0']
- [blocks_uchar_to_float_0, '0', blocks_multiply_const_vxx_scale, '0']
- [image_byte_source_0, '0', blocks_uchar_to_float_0, '0']
- [pilot_sync_0, '0', blocks_multiply_const_vxx_1, '0']
- [uhd_usrp_source_0, '0', blocks_rotator_cc_rx, '0']
- [uhd_usrp_source_0, '0', qtgui_time_sink_x_1_1, '0']
- [virtual_source_0, '0', blocks_complex_to_magphase_0, '0']
- [virtual_source_1, '0', blocks_phase_shift_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
