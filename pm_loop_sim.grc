options:
  parameters:
    comment: |-
      Software equivalent-channel simulation of the 900 MHz PM image link.
      A true sampled 900 MHz carrier requires >1.8 GS/s. This graph therefore
      represents the 900 MHz RF center with a 100 kHz complex low IF while
      preserving phase modulation, channel impairments, and receiver behavior.
    description: PM image transmitter, 900 MHz equivalent channel, and receiver
    generate_options: no_gui
    id: pm_loop_sim
    output_language: python
    run_options: run
    title: PM Loop Software Simulation
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    comment: Complex-envelope sample rate
    value: 0.5e6
  states: {}
- name: rf_freq
  id: variable
  parameters:
    comment: Simulated RF center frequency (metadata for equivalent channel)
    value: 900e6
  states: {}
- name: sim_if
  id: variable
  parameters:
    comment: Sampled low IF representing the 900 MHz RF carrier
    value: 100e3
  states: {}
- name: frame_width
  id: variable
  parameters:
    value: '1920'
  states: {}
- name: frame_height
  id: variable
  parameters:
    value: '1080'
  states: {}
- name: max_phase
  id: variable
  parameters:
    comment: PM peak phase
    value: math.pi/3
  states: {}
- name: noise_voltage
  id: variable
  parameters:
    comment: Complex AWGN voltage
    value: '0.01'
  states: {}
- name: freq_offset_hz
  id: variable
  parameters:
    comment: Channel carrier-frequency offset
    value: '0'
  states: {}
- name: channel_taps
  id: variable
  parameters:
    comment: Multipath taps
    value: '[1.0+0.0j]'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: image_byte_source_0
  id: epy_block
  parameters:
    _source_code: from _image_source_impl import image_byte_source
    comment: Single image frame with Barker sync and pilot
    image_path: '"/home/ray/Project/wireless-cam/scene1920x1080.jpg"'
    repeat: 'False'
  states: {}
- name: blocks_uchar_to_float_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_scale
  id: blocks_multiply_const_vxx
  parameters:
    comment: Normalize image bytes
    const: 1.0/255.0
    type: float
  states: {}
- name: blocks_multiply_const_vxx_phase
  id: blocks_multiply_const_vxx
  parameters:
    comment: Map grayscale to PM phase
    const: max_phase
    type: float
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    comment: Unit magnitude
    const: '1'
    type: float
  states: {}
- name: blocks_magphase_to_complex_0
  id: blocks_magphase_to_complex
  parameters:
    comment: PM complex envelope
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle2
  parameters:
    comment: Software timing for the simulated link
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_rotator_cc_tx
  id: blocks_rotator_cc
  parameters:
    comment: 900 MHz RF upconversion represented at sampled low IF
    phase_inc: 2*math.pi*sim_if/samp_rate
  states: {}
- name: fir_filter_channel
  id: fir_filter_xxx
  parameters:
    comment: One-to-one multipath channel
    decim: '1'
    taps: channel_taps
    type: ccc
  states: {}
- name: blocks_rotator_cc_cfo
  id: blocks_rotator_cc
  parameters:
    comment: Channel carrier-frequency offset
    phase_inc: 2*math.pi*freq_offset_hz/samp_rate
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: noise_voltage
    comment: Complex AWGN
    noise_type: analog.GR_GAUSSIAN
    seed: '42'
    type: complex
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    comment: Add channel noise
    type: complex
  states: {}
- name: blocks_rotator_cc_rx
  id: blocks_rotator_cc
  parameters:
    comment: Receiver downconversion from equivalent IF
    phase_inc: '-2*math.pi*sim_if/samp_rate'
  states: {}
- name: blocks_complex_to_magphase_0
  id: blocks_complex_to_magphase
  parameters:
    comment: PM phase detector
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    comment: Discard magnitude output
    type: float
  states: {}
- name: pilot_sync_0
  id: epy_block
  parameters:
    _source_code: from _pilot_sync_impl import pilot_sync
    comment: Barker synchronization and pilot phase correction
    frame_size: frame_width*frame_height
    pilot_len: '1024'
    sync_len: '416'
  states: {}
- name: blocks_multiply_const_vxx_rx
  id: blocks_multiply_const_vxx
  parameters:
    comment: Convert corrected phase to normalized grayscale
    const: 3/math.pi
    type: float
  states: {}
- name: analog_rail_ff_0
  id: analog_rail_ff
  parameters:
    comment: Prevent uint8 wraparound
    hi: '1'
    lo: '0'
  states: {}
- name: blocks_float_to_uchar_0
  id: blocks_float_to_uchar
  parameters:
    bias: '0'
    scale: '255'
    vlen: '1'
  states: {}
- name: image_byte_sink_0
  id: epy_block
  parameters:
    _source_code: from _image_sink_impl import image_byte_sink
    display: 'False'
    height: frame_height
    output_path: '"/home/ray/Project/wireless-cam/received_sim.png"'
    save_sequence: 'False'
    skip_each_frame: '0'
    width: frame_width
  states: {}
- name: blocks_file_sink_tx_phase
  id: blocks_file_sink
  parameters:
    comment: Transmit PM phase capture
    file: /home/ray/Project/wireless-cam/phase_tx_sim.dat
    type: float
  states: {}
- name: blocks_file_sink_rx_phase
  id: blocks_file_sink
  parameters:
    comment: Received phase capture after downconversion
    file: /home/ray/Project/wireless-cam/phase_rx_sim.dat
    type: float
  states: {}

connections:
- [analog_const_source_x_0, '0', blocks_magphase_to_complex_0, '0']
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '1']
- [analog_rail_ff_0, '0', blocks_float_to_uchar_0, '0']
- [blocks_add_xx_0, '0', blocks_rotator_cc_rx, '0']
- [blocks_complex_to_magphase_0, '0', blocks_null_sink_0, '0']
- [blocks_complex_to_magphase_0, '1', blocks_file_sink_rx_phase, '0']
- [blocks_complex_to_magphase_0, '1', pilot_sync_0, '0']
- [blocks_float_to_uchar_0, '0', image_byte_sink_0, '0']
- [blocks_magphase_to_complex_0, '0', blocks_throttle_0, '0']
- [blocks_multiply_const_vxx_phase, '0', blocks_file_sink_tx_phase, '0']
- [blocks_multiply_const_vxx_phase, '0', blocks_magphase_to_complex_0, '1']
- [blocks_multiply_const_vxx_rx, '0', analog_rail_ff_0, '0']
- [blocks_multiply_const_vxx_scale, '0', blocks_multiply_const_vxx_phase, '0']
- [blocks_rotator_cc_cfo, '0', blocks_add_xx_0, '0']
- [blocks_rotator_cc_rx, '0', blocks_complex_to_magphase_0, '0']
- [blocks_rotator_cc_tx, '0', fir_filter_channel, '0']
- [blocks_throttle_0, '0', blocks_rotator_cc_tx, '0']
- [blocks_uchar_to_float_0, '0', blocks_multiply_const_vxx_scale, '0']
- [fir_filter_channel, '0', blocks_rotator_cc_cfo, '0']
- [image_byte_source_0, '0', blocks_uchar_to_float_0, '0']
- [pilot_sync_0, '0', blocks_multiply_const_vxx_rx, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
