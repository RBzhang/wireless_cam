options:
  parameters:
    generate_options: qt_gui
    id: pm_rx_usrp
    output_language: python
    title: pm_rx_usrp
  states: {}

blocks:
- name: dac_samp_rate
  id: variable
  parameters:
    comment: TX DAC symbol/sample rate for Barker chips and image samples
    value: 100e3
  states: {}
- name: frame_height
  id: variable
  parameters:
    value: '500'
  states: {}
- name: frame_width
  id: variable
  parameters:
    value: '500'
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '30'
    value: '1'
  states: {}
- name: if_freq
  id: variable
  parameters:
    value: 10e3
  states: {}
- name: image_oversample
  id: variable
  parameters:
    comment: RX samples per TX image sample
    value: max(1, int(round(samp_rate/dac_samp_rate)))
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 200e3
  states: {}
- name: sync_len
  id: variable
  parameters:
    comment: Barker-13 length after RX oversampling
    value: 13*int(round(32*samp_rate/dac_samp_rate))
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '1'
    type: complex
  states: {}
- name: analog_rail_ff_0
  id: analog_rail_ff
  parameters:
    hi: '1'
    lo: '0'
  states: {}
- name: band_reject_filter_0
  id: band_reject_filter
  parameters:
    comment: Reject downconverted LO/DC leakage and IQ image at +/-100 kHz
    decim: '1'
    gain: '1'
    high_cutoff_freq: 110e3
    low_cutoff_freq: 90e3
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 5e3
    win: window.WIN_HAMMING
  states: {state: disabled}
- name: blocks_complex_to_magphase_0
  id: blocks_complex_to_magphase
  parameters: {}
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: phase_rx.dat
    type: float
  states: {}
- name: blocks_float_to_uchar_0
  id: blocks_float_to_uchar
  parameters:
    bias: '0'
    scale: '255'
    vlen: '1'
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    comment: divide pi/3
    const: 3/math.pi
    type: float
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_rotator_cc_rx
  id: blocks_rotator_cc
  parameters:
    phase_inc: '-2*math.pi*if_freq/samp_rate'
  states: {}
- name: blocks_rotator_cc_rx_0
  id: blocks_rotator_cc
  parameters:
    phase_inc: 2*math.pi*if_freq/samp_rate
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: from _image_sink_impl import image_byte_sink
    display: 'True'
    height: frame_height
    output_path: '"received.png"'
    save_sequence: 'False'
    skip_each_frame: '0'
    width: frame_width
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: pilot_sync_0
  id: epy_block
  parameters:
    _source_code: from _pilot_sync_impl import pilot_sync
    amp_thresh: '0.4'
    auto_phase_scale: 'True'
    corr_thresh: '0.90'
    frame_size: frame_width*frame_height
    image_oversample: image_oversample
    noise_thresh: '0.35'
    sync_len: sync_len
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    name: '"Corrected"'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    name: '"Phase In"'
    size: '6720'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_1_1
  id: qtgui_time_sink_x
  parameters:
    name: '"IQ In"'
    size: '6720'
    srate: samp_rate
    type: complex
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    center_freq0: 400e6
    dev_args: '""'
    gain0: '0'
    len_tag_name: ''
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    bw0: 5*samp_rate
    center_freq0: 400e6
    gain0: gain
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {}

connections:
- [analog_const_source_x_0, '0', blocks_rotator_cc_rx_0, '0']
- [analog_rail_ff_0, '0', blocks_float_to_uchar_0, '0']
- [band_reject_filter_0, '0', blocks_complex_to_magphase_0, '0']
- [blocks_complex_to_magphase_0, '0', blocks_null_sink_0, '0']
- [blocks_complex_to_magphase_0, '1', blocks_file_sink_0, '0']
- [blocks_complex_to_magphase_0, '1', pilot_sync_0, '0']
- [blocks_complex_to_magphase_0, '1', qtgui_time_sink_x_1, '0']
- [blocks_float_to_uchar_0, '0', epy_block_0, '0']
- [blocks_multiply_const_vxx_1, '0', analog_rail_ff_0, '0']
- [blocks_multiply_const_vxx_1, '0', qtgui_time_sink_x_0, '0']
- [blocks_rotator_cc_rx, '0', band_reject_filter_0, '0']
- [blocks_rotator_cc_rx, '0', blocks_complex_to_magphase_0, '0']
- [blocks_rotator_cc_rx, '0', qtgui_time_sink_x_1_1, '0']
- [blocks_rotator_cc_rx_0, '0', uhd_usrp_sink_0, '0']
- [pilot_sync_0, '0', blocks_multiply_const_vxx_1, '0']
- [uhd_usrp_source_0, '0', blocks_rotator_cc_rx, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
