options:
  parameters:
    generate_options: qt_gui
    generator_class_name: PythonQtGuiGenerator
    generator_module: gnuradio.grc.workflows.python_qt_gui
    id: pm_tx
    output_language: python
    title: pm_tx
  states: {}

blocks:
- name: gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.5'
  states: {}
- name: max_phase
  id: variable
  parameters:
    value: math.pi/3
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '1'
    type: float
  states: {}
- name: blocks_complex_to_magphase_0
  id: blocks_complex_to_magphase
  parameters: {}
  states: {}
- name: blocks_float_to_uchar_0
  id: blocks_float_to_uchar
  parameters:
    bias: '0'
    scale: '255'
    vlen: '1'
  states: {}
- name: blocks_magphase_to_complex_0
  id: blocks_magphase_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    comment: multiply with max_phase
    const: max_phase
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    comment: divide pi/3
    const: 3/math.pi
    type: float
  states: {}
- name: blocks_multiply_const_vxx_2
  id: blocks_multiply_const_vxx
  parameters:
    const: gain
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_scale
  id: blocks_multiply_const_vxx
  parameters:
    const: 1.0/255.0
    type: float
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_phase_shift_0
  id: blocks_phase_shift
  parameters:
    is_radians: 'True'
    shift: math.pi/3
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    noise_type: analog.GR_GAUSSIAN
    output_type: complex
    seed: '0'
    type: complex
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: blocks_uchar_to_float_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: from _image_sink_impl import image_byte_sink
    display: 'True'
    height: '1080'
    output_path: '"/home/ray/Project/wireless-cam/received.png"'
    save_sequence: 'False'
    skip_each_frame: '1040'
    width: '1920'
  states: {}
- name: image_byte_source_0
  id: epy_block
  parameters:
    _source_code: from _image_source_impl import image_byte_source
    image_path: '"/home/ray/Project/wireless-cam/scene1920x1080.jpg"'
    repeat: 'True'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: pilot_sync_0
  id: epy_block
  parameters:
    _source_code: from _pilot_sync_impl import pilot_sync
    diff_thresh: '0.3'
    pilot_len: '1024'
    sync_len: '16'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: rx
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: tx
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: rx
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: tx
  states: {}

connections:
- [analog_const_source_x_0, '0', blocks_magphase_to_complex_0, '0']
- [blocks_complex_to_magphase_0, '0', blocks_null_sink_0, '0']
- [blocks_complex_to_magphase_0, '1', pilot_sync_0, '0']
- [blocks_float_to_uchar_0, '0', epy_block_0, '0']
- [blocks_magphase_to_complex_0, '0', virtual_sink_1, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_magphase_to_complex_0, '1']
- [blocks_multiply_const_vxx_1, '0', blocks_float_to_uchar_0, '0']
- [blocks_multiply_const_vxx_2, '0', blocks_phase_shift_0, '0']
- [blocks_multiply_const_vxx_scale, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_add_xx_0, '0', blocks_complex_to_magphase_0, '0']
- [blocks_phase_shift_0, '0', blocks_add_xx_0, '0']
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '1']
- [blocks_throttle2_0, '0', blocks_uchar_to_float_0, '0']
- [blocks_uchar_to_float_0, '0', blocks_multiply_const_vxx_scale, '0']
- [image_byte_source_0, '0', blocks_throttle2_0, '0']
- [pilot_sync_0, '0', blocks_multiply_const_vxx_1, '0']
- [virtual_source_1, '0', blocks_multiply_const_vxx_2, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
